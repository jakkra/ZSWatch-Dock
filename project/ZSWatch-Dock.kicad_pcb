# Repository jakkra/ZSWatch-Dock

File README.md:

# ZSWatch-Dock

## Table of Contents

- [ZSWatch-Dock](#zswatch-dock)
  - [Table of Contents](#table-of-contents)
  - [About](#about)
  - [Configurations](#configurations)
  - [Dock connector](#dock-connector)
  - [Directory structure](#directory-structure)
  - [Purchasing](#purchasing)
  - [Maintainer](#maintainer)

## About

Programming and charging dock for the [ZSWatch](https://github.com/jakkra/ZSWatch).

Please check the [wiki](https://github.com/jakkra/ZSWatch/wiki) for more information about the project.

## Configurations

The dock can be used with an integrated Segger J-Link debugger or with an external Serial Wire Debugger (SWD) with an [10-pol ARM Cortex JTAG SWD](https://developer.arm.com/documentation/101416/0100/Hardware-Description/Target-Interfaces/Cortex-Debug--10-pin-) connector.

## Dock connector

The pinout for the dock connector is shown below.

<table class="tg">
<thead>
  <tr>
    <th class="tg-0pky"></th>
    <th class="tg-0pky">Pin</th>
    <th class="tg-0pky">Description</th>
  </tr>
</thead>
<tbody>
  <tr>
    <td class="tg-0pky" rowspan="5"></td>
    <td class="tg-0pky">1</td>
    <td class="tg-0pky">VBUS (+5 V)</td>
  </tr>
  <tr>
    <td class="tg-0pky">2</td>
    <td class="tg-0pky">GND</td>
  </tr>
  <tr>
    <td class="tg-0pky">3</td>
    <td class="tg-0pky">SEL</td>
  </tr>
  <tr>
    <td class="tg-0lax">4</td>
    <td class="tg-0lax">D- / SWDIO</td>
  </tr>
  <tr>
    <td class="tg-0lax">5</td>
    <td class="tg-0lax">D+ / SWDCLK</td>
  </tr>
</tbody>
</table>

| SEL  | Function       |
|------|----------------|
|`LOW` | USB            |
|`HIGH`| SWD (Default)  |

## Directory structure

- `cad`: 3D model of the complete PCB
- `docs`: All kind of project documentation
- `project`: KiCad project for the PCB

## Purchasing

Please open `ZSWatch-Dock-navigate.html` and use the files listed under `purchasing` for ordering a PCB.

## Maintainer

- [Daniel Kampert](mailto:daniel.kameprt@kampis-elektroecke.de)
- [Jakob Krantz](mail@jakobkrantz.se)

## KiCad design project/ZSWatch-Dock.kicad_pcb

Parts:
C101: 10u; C_0603_1608Metric
C102, C104, C108, C109, C110, C111, C112, C113: 100n; C_0603_1608Metric
C103: 22u; C_0603_1608Metric
C105: 470p; C_0603_1608Metric
C106: 1u; C_0603_1608Metric
C107: 2u2; C_0603_1608Metric
D101: STATUS; LED_0603_1608Metric
D102: DEBUG; LED_0603_1608Metric
D103: CHARGE; LED_0603_1608Metric
IC101: XC9265C181MR-G; SOT-25-5
IC102: TS3USB221A; UQFN-10_1.55x2.05mm_P0.5mm
IC103: MIC5219-3.3YM5; SOT-23-5
IC104: NTS0104GU12; XQFN-12-1.7x2mm_P0.4mm
IC105: STM32F072CBT6; LQFP-48_7x7mm_P0.5mm
IC106: LM66200; SOT-5X3-8
L101: 10u; L_0603_1608Metric
Q101: BSH205G2AR; SOT-23
R101, R102, R108, R109, R110, R111: 0R; R_0603_1608Metric
R103: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R104: 1k; R_0603_1608Metric
R105, R106, R107: 100k; R_0603_1608Metric
R112, R117, R118: 220R; R_0603_1608Metric
R113, R114, R115, R116: 5k1; R_0603_1608Metric
R119: 620R; R_0603_1608Metric
SW101: SEL; SW_SPDT_PCM12
SW102: CHARGE; SW_SPDT_PCM12
X101: WATCH; PinHeader_1x05_P2.54mm_Vertical
X102: DEBUG; SHF-105-01-L-D-SM-TR
X103: Current; PinHeader_1x02_P2.54mm_Horizontal; not fitted
X104: DEBUG; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
X105: DATA; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal

Connections:
+1V8: C103.1, C108.1, IC101.4 (VOUT), IC104.1 (VCCA), L101.2, R102.1
+3V3: C104.1, C106.1, C107.1, C109.1, C110.1, C111.1, C112.1, C113.1, D101.2 (A), D102.2 (A), IC102.10 (VDD), IC103.5 (OUT), IC104.11 (VCCB), IC104.12 (OE), IC105.1 (VBAT), IC105.9 (VDDA), IC105.24 (VDD), IC105.36 (VDDIO), IC105.48 (VDD), R101.2, R105.1
/SWDCLK: IC105.12 (PA2), R111.2, R112.2
/SWDIO: IC104.7 (B4), IC105.14 (PA4), R110.2
CHARGE: Q101.1 (G), R106.1, R119.2, SW102.3 (C)
D+/SWDCLK: IC102.8 (D+), R109.2, X101.1
D-/SWDIO: IC102.7 (D-), R108.2, X101.2
DEBUG: R118.2, X102.9 (GNDDetect)
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, IC101.2 (GND), IC102.5 (GND), IC103.2 (GND), IC104.6 (GND), IC105.8 (GND), IC105.23 (GND), IC105.35 (GND), IC105.44 (BOOT0), IC105.47 (GND), IC106.1 (GND), IC106.4 (~ON), IC106.5 (GND), R107.2, R113.2, R114.1, R115.2, R116.1, SW101.2 (B), SW102.2 (B), X101.4, X102.3 (GND), X102.5 (GND), X104.A1 (GND), X104.A12 (GND), X104.B1 (GND), X104.B12 (GND), X104.S1 (SHIELD), X105.A1 (GND), X105.A12 (GND), X105.B1 (GND), X105.B12 (GND), X105.S1 (SHIELD)
unnamed: D101.1 (K), R117.1
unnamed: D102.1 (K), R118.1
unnamed: D103.1 (K), R119.1
unnamed: IC101.5 (LX), L101.1
unnamed: IC102.6 (~OE), R107.1
unnamed: C105.1, IC103.4 (BP)
unnamed: IC104.8 (B3), R112.1
unnamed: IC106.3 (VIN1), X104.A4 (VBUS), X104.A9 (VBUS), X104.B4 (VBUS), X104.B9 (VBUS)
unnamed: IC106.6 (VIN2), X105.A4 (VBUS), X105.A9 (VBUS), X105.B4 (VBUS), X105.B9 (VBUS)
unnamed: Q101.3 (D), R103.1, X103.1
unnamed: R104.2, SW101.3 (C)
unnamed: R103.2, X101.5, X103.2
unnamed: R101.1, R102.2, X102.1 (VTref)
unnamed: R113.1, X104.A5 (CC1)
unnamed: R114.2, X104.B5 (CC2)
unnamed: R115.1, X105.A5 (CC1)
unnamed: R116.2, X105.B5 (CC2)
SEL_SWD: C102.1, IC102.9 (S), R104.1, R105.2, X101.3
STATUS: IC105.10 (PA0), R117.2
STM32_RESETn: IC105.7 (~Reset), X102.10 (~RESET)
STM32_SWDCLK: IC105.37 (PA14), R111.1, X102.4 (SWDCLK/TCK)
STM32_SWDIO: IC105.34 (PA13), R110.1, X102.2 (SWDIO/TMS)
SWDCLK_WATCH: IC102.3 (2D+), IC104.4 (A3), R109.1
SWDIO_WATCH: IC102.4 (2D-), IC104.5 (A4), R108.1
USB1_DATA_N: IC105.32 (PA11), X104.A7 (D-), X104.B7 (D-)
USB1_DATA_P: IC105.33 (PA12), X104.A6 (D+), X104.B6 (D+)
USB2_DATA_N: IC102.2 (1D-), X105.A7 (D-), X105.B7 (D-)
USB2_DATA_P: IC102.1 (1D+), X105.A6 (D+), X105.B6 (D+)
VBUS: C101.1, D103.2 (A), IC101.1 (VIN), IC101.3 (EN), IC103.1 (IN), IC103.3 (EN), IC106.2 (VOUT), IC106.7 (VOUT), Q101.2 (S), R106.2

Notes on the sheet:
STM32 Bridge
LEDs
USB / SWD Switch
NOTE: SEL must be high in default mode because in revisions <5 SEL is used as MCU reset.
1V8 Regulator
Interface
NOTE: Change the hole size of the watch connector to 1.4 mm
S Channel Function L HSD1+ and HSD1- USB H HSD2+ and HSD2- SWD (Default)
Debug connector
USB
3V3 Regulator
NOTE: The SWD bridge is needed when the USB option isn´t selected.

Board: 2 copper layers, 50.0 x 55.0 mm, 57 parts (0 on the bottom side), 38 nets.

Other parts of the board:
kibuzzard-65B413A8: G***; kibuzzard-65B413A8
kibuzzard-65B413B7: G***; kibuzzard-65B413B7
kibuzzard-65B41384: G***; kibuzzard-65B41384
kibuzzard-66A144A4: G***; kibuzzard-66A144A4
kibuzzard-6522ABB2: G***; kibuzzard-6522ABB2
kibuzzard-6522ABCA: G***; kibuzzard-6522ABCA
kibuzzard-6525026C: G***; kibuzzard-6525026C

## Commit log

2023-08-21 Initial ZSWatch dock PCB moved from main ZSWatch repo to its own.
2023-08-30 Prepare for production, add production files
2023-09-02 - Add missing 3D model for IC1 - Adjust silkscreen on the botton - Add right footprint for debug connector - Generate new production data - Add BOM variants for option with and without J-Link - Add m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
2023-09-25 - Reorganize the production files and prepare everything for an easy ordering at PCBWay - Replace schematic symbol for debug connector with standard KiCad part - Enable print part value option in Ger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
2023-09-27 - Sync designators in BOM with Schematics - Update all production files for the configuration with J-Link
2023-09-29 - Add signal names on silkscreen for watch connector - Add production data for variant without J-Link
2023-09-30 - Add blue color to PCB settings - Add surface option to PCB settings
2023-10-01 - Streamline documentation and production files - Ready to merge
2023-10-01 Resize dock preview image, because it was too large
2023-10-04 Initialize branch, add dip switch to enable / disable charging
2023-10-10 - Add QR code with link to GitHub repository - Add switch to enable / disable charging - Remove reset line from STM32 to the watch connector
2023-10-10 fixup! - Add QR code with link to GitHub repository - Add switch to enable / disable charging - Remove reset line from STM32 to the watch connector
2023-11-08 - Fix wrong part number of 10 uH inductor and replace it by the right one
2023-11-30 - Fix wrong part number for inductor
2024-01-25 Add KiBot workflow
2024-01-25 Remove old production directory
2024-01-25 Split up gitignore
2024-01-25 Fix wrong KiBot variant names
2024-01-26 Architecture.drawio eingefügt
2024-01-26 Import diagram from Google Drive
2024-01-26 Unbenanntes Diagramm.drawio eingefügt
2024-01-26 Fix wrong logic for SEL pin to align it with watch revisions 1 to 4
2024-01-26 Fix wrong documentation for SEL pin
2024-01-26 Add second USB interface, rename variants
2024-01-30 - Remove old documentation - Increase drill hole size for watch connector to 1.4 mm - Add mounting holes for a zipper as cable protection - Move mounting holes to a new position into the corners - Se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
2024-01-30 Remove 3V3 regulator in minimal variant
2024-01-30 Add jumper to select the right voltage for VTarget on STM32 SWD
2024-01-30 Move the LEDs a bit into the PCB and increase the space between them so a light pipe can be used
2024-01-30 Remove watch connector from BOM and from 3D data
2024-01-30 Move Segger logo back to silkscreen layer
2024-02-02 Add Segger J-Link OB documentation for STM32
2024-02-02 Fix wrong direction for SWDCLK_WATCH signal in Schematics
2024-02-02 Add note for setting SEL to high per default to support rev <5
2024-02-02 Add debounce capacitor to SEL-Switch
2024-02-02 Change power supply for CHARGE LED to VBUS
2024-02-02 Remove STATUS LED in minimal variant
2024-02-02 Fix random error 404 issue in CI/CD pipeline
2024-02-02 Add debounce capacitor for SEL pin to reduced variant, remove STATUS LED in reduced variant
2024-02-02 Update README, update CHANGELOG
2024-02-04 Dock-Connector.drawio eingefügt
2024-02-04 Dock-Connector.drawio aktualisiert
2024-02-05 Add datasheet downloader to KiBot configuration
2024-02-05 Update zswatch-dock.kibot.yaml
    Add datasheet downloader and navigation results to output file generation
2024-02-05 Update zswatch-dock.kibot.yaml
    Remove Inner1 and Inner2 layer because of Copy+Paste error
2024-02-05 Update zswatch-dock.kibot.yaml
    Fix wrong variants from Copy+Paste error
2024-02-05 Update zswatch-dock.kibot.yaml
    Move Ref Top and Ref Bottom into `purchasing` category
2024-02-06 Change output directory for navigation page
2024-02-07 Cosmetic changes
2024-02-07 Update README.md
    Fix wrong link in license badge
2024-02-07 Add image from CI/CD action
2024-02-20 Remove color information for soldermask from project
2024-03-03 Fix wrong file extension for image
2024-03-03 Change PCB color to blue
2024-03-10 - Add create images directory to CI/CD - Add QR-Code image
2024-03-26 Replace QR code with area for QR code
2024-04-21 - Replace QR code with area for QR code - Add isolation diode to disconnect both VBUS from each other - Add new logo
2024-05-11 - Rename signals
2024-06-19 Update build.yml
    - Update actions/upload-artifact to version 4
    - Add git pull before git push to prevent issues
2024-07-23 Upgrade to KiCAD v8
2024-07-26 Initialize branch for rev 4, add connector for current measurement of the watch
2024-07-26 Replace protection diodes for VBUS with LM66200
2024-07-29 Fix non ideal footprint for NTS0104GU12
2024-08-15 Allow running workflows manually.
2024-08-24 Change resistor for CHARGE LED to 620 Ohms
2024-09-19 Update build.yml
    Fix issue where CI/CD could not create the production directory
2024-09-19 Update build.yml
    Fix directory structure for PCBWay directory
2024-09-19 Update zswatch-dock.kibot.yaml
    Fix wrong zoom and position for 3D rendering in KiBot configuration
2024-09-19 Update build.yml
    Fix CI/CD fail when merging
2024-10-24 Clean up part fields
2024-12-22 Fix typo in 'Order No.' field
2024-12-31 Align CI/CD workflow with watch

Notices in the files:
README.md:
License: GPL 3.0
